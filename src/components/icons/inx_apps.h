#pragma once

#include <GfxRenderer.h>

#include <array>
#include <cstdint>

#include "components/themes/BaseTheme.h"

namespace InxAppIcons {
inline constexpr int size = 32;
inline constexpr int bytes = size * size / 8;
using Icon = std::array<uint8_t, bytes>;


// Derived from Tabler Icons (MIT) and the selected custom artwork.
// See LICENSE.tabler-icons for attribution.
inline constexpr Icon Transfer = {
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf3, 0xff, 0xff, 0xff, 0xe3, 0xff, 0xff, 0xff, 0xc7, 0xff, 0xff, 0xff, 0x8f,
    0xff, 0xff, 0xff, 0x1f, 0xff, 0xff, 0xfe, 0x3f, 0xff, 0xff, 0xfc, 0x7f, 0xff, 0xff, 0xf8, 0x00, 0x00, 0x3f, 0xf8,
    0x00, 0x00, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x00, 0x1f, 0xfc, 0x00, 0x00, 0x1f,
    0xff, 0xff, 0xfe, 0x3f, 0xff, 0xff, 0xfc, 0x7f, 0xff, 0xff, 0xf8, 0xff, 0xff, 0xff, 0xf1, 0xff, 0xff, 0xff, 0xe3,
    0xff, 0xff, 0xff, 0xc7, 0xff, 0xff, 0xff, 0xcf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};

inline constexpr Icon Opds = {
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe1, 0xff, 0xfe, 0x00, 0x01, 0xff, 0xfe, 0x00, 0x09, 0xff, 0xfe, 0x63,
    0x08, 0xff, 0xfe, 0x63, 0x0c, 0xff, 0xfe, 0x63, 0x0c, 0xff, 0xfe, 0x63, 0x04, 0xff, 0xfe, 0x63, 0x26, 0x7f, 0xfe,
    0x63, 0x26, 0x7f, 0xfe, 0x63, 0x26, 0x7f, 0xfe, 0x63, 0x32, 0x7f, 0xfe, 0x63, 0x33, 0x3f, 0xfe, 0x63, 0x33, 0x3f,
    0xfe, 0x63, 0x31, 0x3f, 0xfe, 0x63, 0x38, 0x3f, 0xfe, 0x63, 0x38, 0x9f, 0xfe, 0x63, 0x38, 0x9f, 0xfe, 0x00, 0x28,
    0x1f, 0xff, 0x00, 0x04, 0x0f, 0xff, 0xff, 0xe0, 0x1f, 0xff, 0xff, 0xf0, 0x3f, 0xff, 0xff, 0xf8, 0x7f, 0xff, 0xff,
    0xfc, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};

inline constexpr Icon WeRead = {
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0x00, 0x00, 0x1f, 0xf0, 0x00, 0x00,
    0x0f, 0xe0, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x07, 0xe0, 0x00,
    0x00, 0x07, 0xe0, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x01, 0x87, 0xe0, 0x00, 0x07, 0xe7, 0xe0, 0x00, 0x07, 0xf7, 0xe0,
    0x00, 0x0f, 0xbf, 0xe0, 0x00, 0x0f, 0xff, 0xe0, 0x00, 0x0f, 0xff, 0xe0, 0x00, 0x07, 0xf7, 0xe0, 0x00, 0x07, 0xe7,
    0xe0, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x07, 0xff, 0xfe, 0x7f,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};

inline constexpr Icon ReadingStats = {
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0xe3, 0xc7, 0xff, 0xff, 0xe3,
    0xc7, 0xff, 0xff, 0xe3, 0xc0, 0x3f, 0xff, 0xe3, 0xc0, 0x1f, 0xff, 0xe3, 0xc7, 0x8f, 0xff, 0xe3, 0xc7, 0x8f, 0xff,
    0xe3, 0xc7, 0x8f, 0xf8, 0x03, 0xc7, 0x8f, 0xf8, 0x03, 0xc7, 0x8f, 0xf1, 0xe3, 0xc7, 0x8f, 0xf1, 0xe3, 0xc7, 0x8f,
    0xf1, 0xe3, 0xc7, 0x8f, 0xf1, 0xe3, 0xc7, 0x8f, 0xf1, 0xe3, 0xc7, 0x8f, 0xf1, 0xe3, 0xc7, 0x8f, 0xf1, 0xe3, 0xc3,
    0x8f, 0xf0, 0x00, 0x00, 0x0f, 0xf0, 0x00, 0x00, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};

inline constexpr Icon AirPage = {
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x1f,
    0xff, 0xff, 0x00, 0x0f, 0xff, 0xfe, 0x00, 0x07, 0xff, 0xfe, 0x7f, 0x83, 0xff, 0xfe, 0x7f, 0x91, 0xff, 0xfe, 0x7f,
    0x98, 0xff, 0xfe, 0x7f, 0x80, 0x7f, 0xfe, 0x7f, 0xc0, 0x7f, 0xfe, 0x7f, 0xfe, 0x7f, 0xfe, 0x7f, 0xfe, 0x7f, 0xfe,
    0x7e, 0x7e, 0x7f, 0xfe, 0x7c, 0x3e, 0x7f, 0xfe, 0x78, 0x1e, 0x7f, 0xfe, 0x70, 0x0e, 0x7f, 0xfe, 0x72, 0x4e, 0x7f,
    0xfe, 0x7e, 0x7e, 0x7f, 0xfe, 0x7e, 0x7e, 0x7f, 0xfe, 0x7e, 0x7e, 0x7f, 0xfe, 0x7e, 0x7e, 0x7f, 0xfe, 0x7f, 0xfe,
    0x7f, 0xfe, 0x7f, 0xfe, 0x7f, 0xfe, 0x00, 0x00, 0x7f, 0xff, 0x00, 0x00, 0xff, 0xff, 0xc0, 0x03, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};

inline constexpr Icon Standby = {
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x00, 0x3f, 0xf0, 0x00, 0x00,
    0x0f, 0xf0, 0x00, 0x00, 0x0f, 0xe0, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x07, 0xe0, 0x00,
    0x00, 0x07, 0xe0, 0x00, 0x00, 0x07, 0xe0, 0x7c, 0x7f, 0x87, 0xe1, 0xfe, 0x7f, 0xc7, 0xe1, 0xf9, 0x40, 0x47, 0xe3,
    0xf1, 0x60, 0xc7, 0xe3, 0x23, 0x7f, 0xc7, 0xe3, 0x07, 0x41, 0xc7, 0xe3, 0x8f, 0x61, 0xc7, 0xe1, 0xdf, 0x7f, 0xc7,
    0xe1, 0xfe, 0x7f, 0xc7, 0xe0, 0x7c, 0x7f, 0x87, 0xe0, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00,
    0x07, 0xe0, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x07, 0xf0, 0x00, 0x00, 0x0f, 0xf0, 0x00, 0x00, 0x0f, 0xfc, 0x00,
    0x00, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};

struct Bitmap {
  Icon data{};

  constexpr Bitmap() { data.fill(0xff); }

  constexpr void ink(const int x, const int y) {
    if (x < 0 || x >= size || y < 0 || y >= size) return;
    data[y * (size / 8) + x / 8] &= static_cast<uint8_t>(~(1U << (7 - x % 8)));
  }

  constexpr void line(int x0, int y0, const int x1, const int y1) {
    const int dx = x0 < x1 ? x1 - x0 : x0 - x1;
    const int sx = x0 < x1 ? 1 : -1;
    const int dy = y0 < y1 ? y0 - y1 : y1 - y0;
    const int sy = y0 < y1 ? 1 : -1;
    int error = dx + dy;
    while (true) {
      ink(x0, y0);
      if (x0 == x1 && y0 == y1) break;
      const int twice = error * 2;
      if (twice >= dy) {
        error += dy;
        x0 += sx;
      }
      if (twice <= dx) {
        error += dx;
        y0 += sy;
      }
    }
  }

  constexpr void rect(const int x, const int y, const int width, const int height) {
    line(x, y, x + width - 1, y);
    line(x, y + height - 1, x + width - 1, y + height - 1);
    line(x, y, x, y + height - 1);
    line(x + width - 1, y, x + width - 1, y + height - 1);
  }

  constexpr void filledRect(const int x, const int y, const int width, const int height) {
    for (int row = y; row < y + height; ++row) line(x, row, x + width - 1, row);
  }

  constexpr void circle(const int cx, const int cy, const int radius) {
    const int outer = radius * radius;
    const int inner = (radius - 1) * (radius - 1);
    for (int y = -radius; y <= radius; ++y) {
      for (int x = -radius; x <= radius; ++x) {
        const int distance = x * x + y * y;
        if (distance <= outer && distance >= inner) ink(cx + x, cy + y);
      }
    }
  }
};

constexpr Bitmap readingHeatmap() {
  Bitmap icon;
  icon.rect(4, 5, 24, 23);
  for (int x = 10; x <= 22; x += 6) icon.line(x, 5, x, 27);
  for (int y = 11; y <= 23; y += 6) icon.line(4, y, 27, y);
  icon.filledRect(5, 18, 5, 5);
  icon.filledRect(17, 6, 5, 5);
  icon.filledRect(23, 12, 4, 5);
  return icon;
}

constexpr Bitmap readingProfile() {
  Bitmap icon;
  icon.circle(16, 8, 4);
  icon.line(8, 27, 9, 20);
  icon.line(9, 20, 13, 16);
  icon.line(13, 16, 19, 16);
  icon.line(19, 16, 23, 20);
  icon.line(23, 20, 24, 27);
  icon.line(8, 27, 24, 27);
  icon.line(16, 18, 16, 25);
  icon.line(12, 22, 20, 22);
  return icon;
}

constexpr Bitmap achievements() {
  Bitmap icon;
  icon.rect(10, 4, 12, 10);
  icon.line(10, 7, 5, 7);
  icon.line(5, 7, 5, 12);
  icon.line(5, 12, 10, 16);
  icon.line(22, 7, 27, 7);
  icon.line(27, 7, 27, 12);
  icon.line(27, 12, 22, 16);
  icon.line(13, 14, 13, 21);
  icon.line(19, 14, 19, 21);
  icon.rect(10, 21, 12, 4);
  icon.line(7, 28, 25, 28);
  return icon;
}

inline constexpr Icon ReadingHeatmap = readingHeatmap().data;
inline constexpr Icon ReadingProfile = readingProfile().data;
inline constexpr Icon Achievements = achievements().data;

constexpr const uint8_t* get(const UIIcon icon) {
  switch (icon) {
    case UIIcon::Transfer:
      return Transfer.data();
    case UIIcon::Opds:
      return Opds.data();
    case UIIcon::ReadingStats:
      return ReadingStats.data();
    case UIIcon::ReadingHeatmap:
      return ReadingHeatmap.data();
    case UIIcon::ReadingProfile:
      return ReadingProfile.data();
    case UIIcon::Achievements:
      return Achievements.data();
#ifdef ENABLE_CHINESE_VERSION
    case UIIcon::WeRead:
      return WeRead.data();
#endif
    case UIIcon::Standby:
      return Standby.data();
    case UIIcon::AirPage:
      return AirPage.data();
    default:
      return nullptr;
  }
}

inline void draw(const GfxRenderer& renderer, const UIIcon icon, const int x, const int y, const int scale,
                 const bool inverted) {
  const uint8_t* bitmap = get(icon);
  if (!bitmap || scale <= 0) return;
  constexpr int rowBytes = size / 8;
  for (int row = 0; row < size; ++row) {
    for (int column = 0; column < size; ++column) {
      const uint8_t byte = bitmap[row * rowBytes + column / 8];
      if (((byte >> (7 - column % 8)) & 1U) != 0) continue;
      renderer.fillRect(x + column * scale, y + row * scale, scale, scale, !inverted);
    }
  }
}
}  // namespace InxAppIcons
